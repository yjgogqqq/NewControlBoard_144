# Keil uVision project STM32F4.uvprojx, settings and files
target STM32F4 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F4
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM324xG_EVAL
  c misc: --C99
  c include: ../Inc;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/posix;../Middlewares/Third_Party/LwIP/src/include/posix/sys;../Middlewares/Third_Party/LwIP/system/arch;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x68000000 size 0x7ffff
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: etharp.c autoip.c ip4_addr.c igmp.c ip4.c icmp.c dhcp.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: eap.c chap-md5.c ppp.c chap_ms.c lcp.c demand.c eui64.c ipv6cp.c fsm.c mppe.c upap.c magic.c pppcrypt.c pppol2tp.c pppapi.c ccp.c ecp.c ipcp.c multilink.c utils.c chap-new.c vj.c pppos.c auth.c pppoe.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: icmp6.c inet6.c ethip6.c dhcp6.c ip6_addr.c nd6.c mld6.c ip6.c ip6_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/: dns.c pbuf.c memp.c inet_chksum.c sys.c ip.c def.c timeouts.c raw.c netif.c tcp_out.c stats.c udp.c init.c mem.c tcp.c tcp_in.c
    ../Middlewares/Third_Party/LwIP/src/api/: netifapi.c sockets.c netdb.c netbuf.c tcpip.c api_lib.c err.c api_msg.c
    ../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c ethernet.c slipif.c
    ../Middlewares/Third_Party/LwIP/src/apps/tftp/: tftp_server.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_eth.c stm32f4xx_hal_sram.c stm32f4xx_hal_spi.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_gpio.c
  group Application/User
    ../Src/: ethernetif.c stm32f4xx_hal_msp.c main.c gpio.c sdio.c fatfs.c spi.c sd_diskio.c tim.c fsmc.c stm32f4xx_it.c usart.c can.c lwip.c udp_echoserver.c stm324xg_eval_sd.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.1.0
